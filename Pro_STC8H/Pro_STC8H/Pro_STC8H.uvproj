# Keil uVision project Pro_STC8H.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: Pro_STC8H +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: Adc_C51.c bz.c main.c timer.c pwm.c key.c TM1637_drv.c rf_ctrl.c uart1.c e2prom.c
